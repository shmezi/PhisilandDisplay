## sdkconfig.defaults
```kconfig
CONFIG_ESP_WIFI_AP_ISOLATION=n
CONFIG_ESP_WIFI_SOFTAP_SUPPORT=y
CONFIG_LWIP_MAX_ACTIVE_TCP=16
CONFIG_LWIP_TCP_MSL=2000
CONFIG_LWIP_TIME_WAIT_TIMEOUT=2000
```
